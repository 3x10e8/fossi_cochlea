v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
L 9 -7.5 -7.5 -7.5 7.5 {}
L 9 -7.5 -7.5 7.5 -7.5 {}
L 9 7.5 -7.5 7.5 7.5 {}
L 9 -7.5 7.5 7.5 7.5 {}
B 10 -2.5 -2.5 2.5 2.5 {}
