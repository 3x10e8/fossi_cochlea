v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 40 -1410 120 -1410 {}
N 40 -1530 40 -1450 {}
N 40 -1530 120 -1530 {}
C {devices/ipin.sym} 180 -1670 0 0 {name=p1 lab=rst_ext}
C {devices/opin.sym} 200 -1700 0 0 {name=p2 lab=xxx}
C {devices/ipin.sym} 180 -1640 0 0 {name=p3 lab=vpb}
C {devices/ipin.sym} 180 -1610 0 0 {name=p4 lab=inp_i}
C {devices/ipin.sym} 180 -1580 0 0 {name=p5 lab=inp_q}
C {devices/ipin.sym} 260 -1610 0 0 {name=p6 lab=inm_i}
C {devices/ipin.sym} 260 -1580 0 0 {name=p7 lab=inm_q}
C {clkgen/filter_clkgen.sym} 170 -450 0 0 {name=X14}
C {devices/ipin.sym} 250 -1640 0 0 {name=p8 lab=vnb}
C {devices/ipin.sym} 250 -1670 0 0 {name=p9 lab=clk_ext}
C {devices/lab_pin.sym} 220 -1530 2 0 {name=l67 sig_type=std_logic lab=phi1}
C {devices/lab_pin.sym} 220 -1490 0 1 {name=l68 sig_type=std_logic lab=phi2}
C {devices/lab_pin.sym} 220 -1470 0 1 {name=l69 sig_type=std_logic lab=phi2b}
C {devices/lab_pin.sym} 220 -1510 2 0 {name=l70 sig_type=std_logic lab=phi1b}
C {devices/lab_pin.sym} 120 -1450 2 1 {name=l72 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -1430 2 1 {name=l73 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 120 -1360 2 1 {name=l75 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 120 -1280 2 1 {name=l76 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -1260 2 1 {name=l77 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 120 -1190 2 1 {name=l78 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 120 -1110 2 1 {name=l79 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -1090 2 1 {name=l80 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 120 -1020 2 1 {name=l81 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 120 -940 2 1 {name=l82 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -920 2 1 {name=l83 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 120 -850 2 1 {name=l84 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 120 -770 2 1 {name=l85 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -750 2 1 {name=l86 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 120 -680 2 1 {name=l87 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 120 -600 2 1 {name=l88 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -580 2 1 {name=l89 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 220 -1360 2 0 {name=l90 sig_type=std_logic lab=phi1_2}
C {devices/lab_pin.sym} 220 -1170 0 1 {name=l91 sig_type=std_logic lab=phi1b_4}
C {devices/lab_pin.sym} 220 -1000 0 1 {name=l92 sig_type=std_logic lab=phi1b_8}
C {devices/lab_pin.sym} 220 -830 0 1 {name=l93 sig_type=std_logic lab=phi1b_16}
C {devices/lab_pin.sym} 220 -660 0 1 {name=l94 sig_type=std_logic lab=phi1b_32}
C {devices/lab_pin.sym} 220 -490 0 1 {name=l95 sig_type=std_logic lab=phi1b_64}
C {devices/lab_pin.sym} 120 -510 2 1 {name=l96 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 220 -1190 0 1 {name=l97 sig_type=std_logic lab=phi1_4}
C {devices/lab_pin.sym} 220 -1020 0 1 {name=l98 sig_type=std_logic lab=phi1_8}
C {devices/lab_pin.sym} 220 -850 0 1 {name=l99 sig_type=std_logic lab=phi1_16}
C {devices/lab_pin.sym} 220 -680 0 1 {name=l100 sig_type=std_logic lab=phi1_32}
C {devices/lab_pin.sym} 220 -510 0 1 {name=l101 sig_type=std_logic lab=phi1_64}
C {devices/lab_pin.sym} 220 -1340 2 0 {name=l102 sig_type=std_logic lab=phi1b_2}
C {devices/lab_pin.sym} 220 -1320 0 1 {name=l103 sig_type=std_logic lab=phi2_2}
C {devices/lab_pin.sym} 220 -1150 0 1 {name=l104 sig_type=std_logic lab=phi2_4}
C {devices/lab_pin.sym} 220 -980 0 1 {name=l105 sig_type=std_logic lab=phi2_8}
C {devices/lab_pin.sym} 220 -810 0 1 {name=l106 sig_type=std_logic lab=phi2_16}
C {devices/lab_pin.sym} 220 -640 0 1 {name=l107 sig_type=std_logic lab=phi2_32}
C {devices/lab_pin.sym} 220 -470 0 1 {name=l108 sig_type=std_logic lab=phi2_64}
C {devices/lab_pin.sym} 220 -1300 0 1 {name=l109 sig_type=std_logic lab=phi2b_2}
C {devices/lab_pin.sym} 220 -1130 0 1 {name=l110 sig_type=std_logic lab=phi2b_4}
C {devices/lab_pin.sym} 220 -960 0 1 {name=l111 sig_type=std_logic lab=phi2b_8}
C {devices/lab_pin.sym} 220 -790 0 1 {name=l112 sig_type=std_logic lab=phi2b_16}
C {devices/lab_pin.sym} 220 -620 0 1 {name=l113 sig_type=std_logic lab=phi2b_32}
C {devices/lab_pin.sym} 220 -450 0 1 {name=l114 sig_type=std_logic lab=phi2b_64}
C {devices/lab_pin.sym} 120 -430 2 1 {name=l115 sig_type=std_logic lab=vpb}
C {devices/lab_pin.sym} 120 -410 2 1 {name=l116 sig_type=std_logic lab=vnb}
C {devices/lab_pin.sym} 220 -390 2 0 {name=l117 sig_type=std_logic lab=clk_128}
C {devices/lab_pin.sym} 220 -1410 0 1 {name=l6 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 220 -1240 0 1 {name=l7 sig_type=std_logic lab=clk_4}
C {devices/lab_pin.sym} 220 -1070 0 1 {name=l8 sig_type=std_logic lab=clk_8}
C {devices/lab_pin.sym} 220 -900 0 1 {name=l9 sig_type=std_logic lab=clk_16}
C {devices/lab_pin.sym} 220 -730 0 1 {name=l10 sig_type=std_logic lab=clk_32}
C {devices/lab_pin.sym} 220 -560 2 0 {name=l11 sig_type=std_logic lab=clk_64}
C {devices/lab_pin.sym} 220 -430 2 0 {name=l374 sig_type=std_logic lab=cclk_64}
C {devices/lab_pin.sym} 220 -410 2 0 {name=l375 sig_type=std_logic lab=cclkb_64}
C {clkgen/filter_clkgen.sym} 170 -1470 0 0 {name=X8}
C {clkgen/filter_clkgen.sym} 170 -1300 0 0 {name=X9}
C {clkgen/filter_clkgen.sym} 170 -1130 0 0 {name=X10}
C {clkgen/filter_clkgen.sym} 170 -960 0 0 {name=X11}
C {clkgen/filter_clkgen.sym} 170 -790 0 0 {name=X12}
C {clkgen/filter_clkgen.sym} 170 -620 0 0 {name=X13}
C {devices/lab_pin.sym} 220 -1450 2 0 {name=l376 sig_type=std_logic lab=cclk}
C {devices/lab_pin.sym} 220 -1430 2 0 {name=l377 sig_type=std_logic lab=cclkb}
C {devices/lab_pin.sym} 220 -1280 2 0 {name=l378 sig_type=std_logic lab=cclk_2}
C {devices/lab_pin.sym} 220 -1260 2 0 {name=l379 sig_type=std_logic lab=cclkb_2}
C {devices/lab_pin.sym} 220 -1110 2 0 {name=l380 sig_type=std_logic lab=cclk_4}
C {devices/lab_pin.sym} 220 -1090 2 0 {name=l381 sig_type=std_logic lab=cclkb_4}
C {devices/lab_pin.sym} 220 -940 2 0 {name=l382 sig_type=std_logic lab=cclk_8}
C {devices/lab_pin.sym} 220 -920 2 0 {name=l383 sig_type=std_logic lab=cclkb_8}
C {devices/lab_pin.sym} 220 -770 2 0 {name=l384 sig_type=std_logic lab=cclk_16}
C {devices/lab_pin.sym} 220 -750 2 0 {name=l385 sig_type=std_logic lab=cclkb_16}
C {devices/lab_pin.sym} 220 -600 2 0 {name=l386 sig_type=std_logic lab=cclk_32}
C {devices/lab_pin.sym} 220 -580 2 0 {name=l387 sig_type=std_logic lab=cclkb_32}
C {devices/ipin.sym} 180 -1720 0 0 {name=p10 lab=thresh1}
C {devices/ipin.sym} 180 -1690 0 0 {name=p11 lab=thresh2}
C {tryandtest/champa/filter_bank.sym} 430 -1320 0 0 {name=X64}
C {devices/lab_pin.sym} 450 -1480 0 0 {name=l363 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 450 -1460 0 0 {name=l364 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 450 -1440 0 0 {name=l365 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 450 -1420 0 0 {name=l366 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 450 -1400 0 0 {name=l367 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 450 -1380 0 0 {name=l368 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 450 -1500 2 1 {name=l369 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 450 -1520 2 1 {name=l370 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 520 -1600 1 0 {name=l371 sig_type=std_logic lab=phi1}
C {devices/lab_pin.sym} 520 -1300 3 0 {name=l372 sig_type=std_logic lab=phi1b}
C {devices/lab_pin.sym} 540 -1600 3 1 {name=l373 sig_type=std_logic lab=phi2}
C {devices/lab_pin.sym} 540 -1300 1 1 {name=l516 sig_type=std_logic lab=phi2b}
C {devices/lab_pin.sym} 560 -1600 1 0 {name=l517 sig_type=std_logic lab=cclk}
C {devices/lab_pin.sym} 560 -1300 3 0 {name=l522 sig_type=std_logic lab=cclkb}
C {tryandtest/champa/filter_bank.sym} 800 -1320 0 0 {name=X65}
C {devices/lab_pin.sym} 820 -1480 0 0 {name=l523 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 820 -1460 0 0 {name=l528 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 820 -1440 0 0 {name=l529 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 820 -1420 0 0 {name=l534 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 820 -1400 0 0 {name=l535 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 820 -1380 0 0 {name=l546 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 820 -1500 2 1 {name=l547 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 820 -1520 2 1 {name=l548 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 890 -1600 1 0 {name=l549 sig_type=std_logic lab=phi1_2}
C {devices/lab_pin.sym} 890 -1300 3 0 {name=l550 sig_type=std_logic lab=phi1b_2}
C {devices/lab_pin.sym} 910 -1600 3 1 {name=l551 sig_type=std_logic lab=phi2_2}
C {devices/lab_pin.sym} 910 -1300 1 1 {name=l552 sig_type=std_logic lab=phi2b_2}
C {devices/lab_pin.sym} 930 -1600 1 0 {name=l553 sig_type=std_logic lab=cclk_2}
C {devices/lab_pin.sym} 930 -1300 3 0 {name=l554 sig_type=std_logic lab=cclkb_2}
C {tryandtest/champa/filter_bank.sym} 1180 -1320 0 0 {name=X66}
C {devices/lab_pin.sym} 1200 -1480 0 0 {name=l555 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 1200 -1460 0 0 {name=l556 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 1200 -1440 0 0 {name=l557 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 1200 -1420 0 0 {name=l558 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 1200 -1400 0 0 {name=l559 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 1200 -1380 0 0 {name=l560 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 1200 -1500 2 1 {name=l561 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 1200 -1520 2 1 {name=l562 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 1270 -1600 1 0 {name=l563 sig_type=std_logic lab=phi1_4}
C {devices/lab_pin.sym} 1270 -1300 3 0 {name=l564 sig_type=std_logic lab=phi1b_4}
C {devices/lab_pin.sym} 1290 -1600 3 1 {name=l565 sig_type=std_logic lab=phi2_4}
C {devices/lab_pin.sym} 1290 -1300 1 1 {name=l566 sig_type=std_logic lab=phi2b_4}
C {devices/lab_pin.sym} 1310 -1600 1 0 {name=l567 sig_type=std_logic lab=cclk_4}
C {devices/lab_pin.sym} 1310 -1300 3 0 {name=l568 sig_type=std_logic lab=cclkb_4}
C {tryandtest/champa/filter_bank.sym} 1560 -1320 0 0 {name=X67}
C {devices/lab_pin.sym} 1580 -1480 0 0 {name=l569 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 1580 -1460 0 0 {name=l570 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 1580 -1440 0 0 {name=l571 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 1580 -1420 0 0 {name=l572 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 1580 -1400 0 0 {name=l573 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 1580 -1380 0 0 {name=l574 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 1580 -1500 2 1 {name=l575 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 1580 -1520 2 1 {name=l576 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 1650 -1600 1 0 {name=l577 sig_type=std_logic lab=phi1_8}
C {devices/lab_pin.sym} 1650 -1300 3 0 {name=l578 sig_type=std_logic lab=phi1b_8}
C {devices/lab_pin.sym} 1670 -1600 3 1 {name=l579 sig_type=std_logic lab=phi2_8}
C {devices/lab_pin.sym} 1670 -1300 1 1 {name=l580 sig_type=std_logic lab=phi2b_8}
C {devices/lab_pin.sym} 1690 -1600 1 0 {name=l581 sig_type=std_logic lab=cclk_8}
C {devices/lab_pin.sym} 1690 -1300 3 0 {name=l582 sig_type=std_logic lab=cclkb_8}
C {tryandtest/champa/filter_bank.sym} 440 -710 0 0 {name=X68}
C {devices/lab_pin.sym} 460 -870 0 0 {name=l583 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 460 -850 0 0 {name=l584 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 460 -830 0 0 {name=l585 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 460 -810 0 0 {name=l586 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 460 -790 0 0 {name=l587 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 460 -770 0 0 {name=l588 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 460 -890 2 1 {name=l589 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 460 -910 2 1 {name=l590 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 530 -990 1 0 {name=l591 sig_type=std_logic lab=phi1_16}
C {devices/lab_pin.sym} 530 -690 3 0 {name=l592 sig_type=std_logic lab=phi1b_16}
C {devices/lab_pin.sym} 550 -990 3 1 {name=l593 sig_type=std_logic lab=phi2_16}
C {devices/lab_pin.sym} 550 -690 1 1 {name=l594 sig_type=std_logic lab=phi2b_16}
C {devices/lab_pin.sym} 570 -990 1 0 {name=l595 sig_type=std_logic lab=cclk_16}
C {devices/lab_pin.sym} 570 -690 3 0 {name=l596 sig_type=std_logic lab=cclkb_16}
C {tryandtest/champa/filter_bank.sym} 800 -710 0 0 {name=X69}
C {devices/lab_pin.sym} 820 -870 0 0 {name=l597 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 820 -850 0 0 {name=l598 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 820 -830 0 0 {name=l599 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 820 -810 0 0 {name=l600 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 820 -790 0 0 {name=l601 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 820 -770 0 0 {name=l602 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 820 -890 2 1 {name=l603 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 820 -910 2 1 {name=l604 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 890 -990 1 0 {name=l605 sig_type=std_logic lab=phi1_32}
C {devices/lab_pin.sym} 890 -690 3 0 {name=l606 sig_type=std_logic lab=phi1b_32}
C {devices/lab_pin.sym} 910 -990 3 1 {name=l607 sig_type=std_logic lab=phi2_32}
C {devices/lab_pin.sym} 910 -690 1 1 {name=l608 sig_type=std_logic lab=phi2b_32}
C {devices/lab_pin.sym} 930 -990 1 0 {name=l609 sig_type=std_logic lab=cclk_32}
C {devices/lab_pin.sym} 930 -690 3 0 {name=l610 sig_type=std_logic lab=cclkb_32}
C {tryandtest/champa/filter_bank.sym} 1190 -710 0 0 {name=X70}
C {devices/lab_pin.sym} 1210 -870 0 0 {name=l611 sig_type=std_logic lab=inp_i}
C {devices/lab_pin.sym} 1210 -850 0 0 {name=l612 sig_type=std_logic lab=inp_q}
C {devices/lab_pin.sym} 1210 -830 0 0 {name=l613 sig_type=std_logic lab=inm_i}
C {devices/lab_pin.sym} 1210 -810 0 0 {name=l614 sig_type=std_logic lab=inm_q}
C {devices/lab_pin.sym} 1210 -790 0 0 {name=l615 sig_type=std_logic lab=thresh1}
C {devices/lab_pin.sym} 1210 -770 0 0 {name=l616 sig_type=std_logic lab=thresh2}
C {devices/lab_pin.sym} 1210 -890 2 1 {name=l617 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} 1210 -910 2 1 {name=l618 sig_type=std_logic lab=en}
C {devices/lab_pin.sym} 1280 -990 1 0 {name=l619 sig_type=std_logic lab=phi1_64}
C {devices/lab_pin.sym} 1280 -690 3 0 {name=l620 sig_type=std_logic lab=phi1b_64}
C {devices/lab_pin.sym} 1300 -990 3 1 {name=l621 sig_type=std_logic lab=phi2_64}
C {devices/lab_pin.sym} 1300 -690 1 1 {name=l622 sig_type=std_logic lab=phi2b_64}
C {devices/lab_pin.sym} 1320 -990 1 0 {name=l623 sig_type=std_logic lab=cclk_64}
C {devices/lab_pin.sym} 1320 -690 3 0 {name=l624 sig_type=std_logic lab=cclkb_64}
C {devices/lab_pin.sym} 120 -1240 2 1 {name=l1 sig_type=std_logic lab=clk_2}
C {devices/lab_pin.sym} 120 -1070 0 0 {name=l2 sig_type=std_logic lab=clk_4}
C {devices/lab_pin.sym} 120 -900 0 0 {name=l3 sig_type=std_logic lab=clk_8}
C {devices/lab_pin.sym} 120 -730 0 0 {name=l4 sig_type=std_logic lab=clk_16}
C {devices/lab_pin.sym} 120 -560 0 0 {name=l5 sig_type=std_logic lab=clk_32}
C {devices/lab_pin.sym} 120 -390 2 1 {name=l12 sig_type=std_logic lab=clk_64}
C {Clock Synchronizer/synchronizer.sym} -2890 -30 0 0 {name=X1}
C {devices/lab_pin.sym} 40 -1530 2 1 {name=l13 sig_type=std_logic lab=rstb}
C {devices/lab_pin.sym} -230 -1450 2 1 {name=l14 sig_type=std_logic lab=rst_ext}
C {devices/lab_pin.sym} -230 -1410 2 1 {name=l15 sig_type=std_logic lab=clk_ext}
