v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {This flop sets when resetb goes low because we want initial value as 16'b1000000000000000 } 9650 -1860 0 0 0.4 0.4 {}
N 890 -1910 970 -1910 { lab=Clk}
N 1060 -2240 1060 -2220 { lab=Q0}
N 760 -2080 860 -2080 { lab=EN}
N 760 -1980 860 -1980 { lab=RSTB}
N 1200 -2150 1200 -2080 { lab=#net1}
N 1200 -2040 1200 -1970 { lab=#net2}
N 1080 -1950 1080 -1860 { lab=#net3}
N 640 -2170 1080 -2170 { lab=U/D}
N 1080 -2130 1080 -2080 { lab=Q0}
N 1060 -2130 1080 -2130 { lab=Q0}
N 1060 -2220 1060 -2130 { lab=Q0}
N 1080 -2030 1080 -1990 { lab=#net4}
N 660 -2170 660 -1860 { lab=U/D}
N 660 -1860 1000 -1860 { lab=U/D}
N 1200 -2170 1200 -2150 { lab=#net1}
N 1200 -2170 1330 -2170 { lab=#net1}
N 1200 -1970 1200 -1860 { lab=#net2}
N 1200 -1860 1340 -1860 { lab=#net2}
N 1490 -1910 1570 -1910 { lab=Clk}
N 1660 -2240 1660 -2220 { lab=Q1}
N 1360 -1980 1460 -1980 { lab=RSTB}
N 1800 -2150 1800 -2080 { lab=#net5}
N 1800 -2040 1800 -1970 { lab=#net6}
N 1680 -1950 1680 -1860 { lab=#net2}
N 1680 -2130 1680 -2080 { lab=Q1}
N 1660 -2130 1680 -2130 { lab=Q1}
N 1660 -2220 1660 -2130 { lab=Q1}
N 1680 -2030 1680 -1990 { lab=#net7}
N 1800 -2170 1800 -2150 { lab=#net5}
N 1800 -2170 1930 -2170 { lab=#net5}
N 1800 -1970 1800 -1860 { lab=#net6}
N 1800 -1860 1940 -1860 { lab=#net6}
N 1320 -2080 1320 -2060 { lab=#net8}
N 1360 -1860 1600 -1860 { lab=#net2}
N 1360 -2170 1680 -2170 { lab=#net1}
N 1930 -2170 1960 -2170 { lab=#net5}
N 1940 -1860 1960 -1860 { lab=#net6}
N 1330 -2170 1360 -2170 { lab=#net1}
N 1340 -1860 1360 -1860 { lab=#net2}
N 2090 -1910 2170 -1910 { lab=Clk}
N 2260 -2240 2260 -2220 { lab=Q2}
N 1960 -1980 2060 -1980 { lab=RSTB}
N 2400 -2150 2400 -2080 { lab=#net9}
N 2400 -2040 2400 -1970 { lab=#net10}
N 2280 -1950 2280 -1860 { lab=#net6}
N 2280 -2130 2280 -2080 { lab=Q2}
N 2260 -2130 2280 -2130 { lab=Q2}
N 2260 -2220 2260 -2130 { lab=Q2}
N 2280 -2030 2280 -1990 { lab=#net11}
N 2400 -2170 2400 -2150 { lab=#net9}
N 2400 -2170 2530 -2170 { lab=#net9}
N 2400 -1970 2400 -1860 { lab=#net10}
N 2400 -1860 2540 -1860 { lab=#net10}
N 1960 -1860 2200 -1860 { lab=#net6}
N 1960 -2170 2280 -2170 { lab=#net5}
N 2530 -2170 2560 -2170 { lab=#net9}
N 2540 -1860 2560 -1860 { lab=#net10}
N 2690 -1910 2770 -1910 { lab=Clk}
N 2860 -2240 2860 -2220 { lab=Q3}
N 2560 -1980 2660 -1980 { lab=RSTB}
N 3000 -2150 3000 -2080 { lab=#net12}
N 3000 -2040 3000 -1970 { lab=#net13}
N 2880 -1950 2880 -1860 { lab=#net10}
N 2880 -2130 2880 -2080 { lab=Q3}
N 2860 -2130 2880 -2130 { lab=Q3}
N 2860 -2220 2860 -2130 { lab=Q3}
N 2880 -2030 2880 -1990 { lab=#net14}
N 3000 -2170 3000 -2150 { lab=#net12}
N 3000 -2170 3130 -2170 { lab=#net12}
N 3000 -1970 3000 -1860 { lab=#net13}
N 3000 -1860 3140 -1860 { lab=#net13}
N 2560 -1860 2800 -1860 { lab=#net10}
N 2560 -2170 2880 -2170 { lab=#net9}
N 3130 -2170 3160 -2170 { lab=#net12}
N 3140 -1860 3160 -1860 { lab=#net13}
N 3290 -1910 3370 -1910 { lab=Clk}
N 3460 -2240 3460 -2220 { lab=Q4}
N 3160 -1980 3260 -1980 { lab=RSTB}
N 3600 -2150 3600 -2080 { lab=#net15}
N 3600 -2040 3600 -1970 { lab=#net16}
N 3480 -1950 3480 -1860 { lab=#net13}
N 3480 -2130 3480 -2080 { lab=Q4}
N 3460 -2130 3480 -2130 { lab=Q4}
N 3460 -2220 3460 -2130 { lab=Q4}
N 3480 -2030 3480 -1990 { lab=#net17}
N 3600 -2170 3600 -2150 { lab=#net15}
N 3600 -2170 3730 -2170 { lab=#net15}
N 3600 -1970 3600 -1860 { lab=#net16}
N 3600 -1860 3740 -1860 { lab=#net16}
N 3160 -1860 3400 -1860 { lab=#net13}
N 3160 -2170 3480 -2170 { lab=#net12}
N 3730 -2170 3760 -2170 { lab=#net15}
N 3740 -1860 3760 -1860 { lab=#net16}
N 3890 -1910 3970 -1910 { lab=Clk}
N 4060 -2240 4060 -2220 { lab=Q5}
N 3760 -1980 3860 -1980 { lab=RSTB}
N 4200 -2150 4200 -2080 { lab=#net18}
N 4200 -2040 4200 -1970 { lab=#net19}
N 4080 -1950 4080 -1860 { lab=#net16}
N 4080 -2130 4080 -2080 { lab=Q5}
N 4060 -2130 4080 -2130 { lab=Q5}
N 4060 -2220 4060 -2130 { lab=Q5}
N 4080 -2030 4080 -1990 { lab=#net20}
N 4200 -2170 4200 -2150 { lab=#net18}
N 4200 -2170 4330 -2170 { lab=#net18}
N 4200 -1970 4200 -1860 { lab=#net19}
N 4200 -1860 4340 -1860 { lab=#net19}
N 3760 -1860 4000 -1860 { lab=#net16}
N 3760 -2170 4080 -2170 { lab=#net15}
N 4330 -2170 4360 -2170 { lab=#net18}
N 4490 -1910 4570 -1910 { lab=Clk}
N 4660 -2240 4660 -2220 { lab=Q6}
N 4360 -1980 4460 -1980 { lab=RSTB}
N 4800 -2150 4800 -2080 { lab=#net21}
N 4800 -2040 4800 -1970 { lab=#net22}
N 4680 -1950 4680 -1860 { lab=#net19}
N 4680 -2130 4680 -2080 { lab=Q6}
N 4660 -2130 4680 -2130 { lab=Q6}
N 4660 -2220 4660 -2130 { lab=Q6}
N 4680 -2030 4680 -1990 { lab=#net23}
N 4800 -2170 4800 -2150 { lab=#net21}
N 4800 -2170 4930 -2170 { lab=#net21}
N 4800 -1970 4800 -1860 { lab=#net22}
N 4800 -1860 4940 -1860 { lab=#net22}
N 4360 -1860 4600 -1860 { lab=#net19}
N 4360 -2170 4680 -2170 { lab=#net18}
N 4930 -2170 4960 -2170 { lab=#net21}
N 4940 -1860 4960 -1860 { lab=#net22}
N 5090 -1910 5170 -1910 { lab=Clk}
N 5260 -2240 5260 -2220 { lab=Q7}
N 4960 -1980 5060 -1980 { lab=RSTB}
N 5400 -2150 5400 -2080 { lab=#net24}
N 5400 -2040 5400 -1970 { lab=#net25}
N 5280 -1950 5280 -1860 { lab=#net22}
N 5280 -2130 5280 -2080 { lab=Q7}
N 5260 -2130 5280 -2130 { lab=Q7}
N 5260 -2220 5260 -2130 { lab=Q7}
N 5280 -2030 5280 -1990 { lab=#net26}
N 5400 -2170 5400 -2150 { lab=#net24}
N 5400 -2170 5530 -2170 { lab=#net24}
N 5400 -1970 5400 -1860 { lab=#net25}
N 5400 -1860 5540 -1860 { lab=#net25}
N 4960 -1860 5200 -1860 { lab=#net22}
N 4960 -2170 5280 -2170 { lab=#net21}
N 5530 -2170 5560 -2170 { lab=#net24}
N 5540 -1860 5560 -1860 { lab=#net25}
N 4340 -1860 4360 -1860 { lab=#net19}
N 5690 -1910 5770 -1910 { lab=Clk}
N 5860 -2240 5860 -2220 { lab=Q8}
N 5560 -1980 5660 -1980 { lab=RSTB}
N 6000 -2150 6000 -2080 { lab=#net27}
N 6000 -2040 6000 -1970 { lab=#net28}
N 5880 -1950 5880 -1860 { lab=#net25}
N 5880 -2130 5880 -2080 { lab=Q8}
N 5860 -2130 5880 -2130 { lab=Q8}
N 5860 -2220 5860 -2130 { lab=Q8}
N 5880 -2030 5880 -1990 { lab=#net29}
N 6000 -2170 6000 -2150 { lab=#net27}
N 6000 -2170 6130 -2170 { lab=#net27}
N 6000 -1970 6000 -1860 { lab=#net28}
N 6000 -1860 6140 -1860 { lab=#net28}
N 5560 -1860 5800 -1860 { lab=#net25}
N 5560 -2170 5880 -2170 { lab=#net24}
N 6130 -2170 6160 -2170 { lab=#net27}
N 6140 -1860 6160 -1860 { lab=#net28}
N 6290 -1910 6370 -1910 { lab=Clk}
N 6460 -2240 6460 -2220 { lab=Q9}
N 6160 -1980 6260 -1980 { lab=RSTB}
N 6600 -2150 6600 -2080 { lab=#net30}
N 6600 -2040 6600 -1970 { lab=#net31}
N 6480 -1950 6480 -1860 { lab=#net28}
N 6480 -2130 6480 -2080 { lab=Q9}
N 6460 -2130 6480 -2130 { lab=Q9}
N 6460 -2220 6460 -2130 { lab=Q9}
N 6480 -2030 6480 -1990 { lab=#net32}
N 6600 -2170 6600 -2150 { lab=#net30}
N 6600 -2170 6730 -2170 { lab=#net30}
N 6600 -1970 6600 -1860 { lab=#net31}
N 6600 -1860 6740 -1860 { lab=#net31}
N 6160 -1860 6400 -1860 { lab=#net28}
N 6160 -2170 6480 -2170 { lab=#net27}
N 6730 -2170 6760 -2170 { lab=#net30}
N 6740 -1860 6760 -1860 { lab=#net31}
N 6890 -1910 6970 -1910 { lab=Clk}
N 7060 -2240 7060 -2220 { lab=Q10}
N 6760 -1980 6860 -1980 { lab=RSTB}
N 7200 -2150 7200 -2080 { lab=#net33}
N 7200 -2040 7200 -1970 { lab=#net34}
N 7080 -1950 7080 -1860 { lab=#net31}
N 7080 -2130 7080 -2080 { lab=Q10}
N 7060 -2130 7080 -2130 { lab=Q10}
N 7060 -2220 7060 -2130 { lab=Q10}
N 7080 -2030 7080 -1990 { lab=#net35}
N 7200 -2170 7200 -2150 { lab=#net33}
N 7200 -2170 7330 -2170 { lab=#net33}
N 7200 -1970 7200 -1860 { lab=#net34}
N 7200 -1860 7340 -1860 { lab=#net34}
N 6760 -1860 7000 -1860 { lab=#net31}
N 6760 -2170 7080 -2170 { lab=#net30}
N 7330 -2170 7360 -2170 { lab=#net33}
N 7490 -1910 7570 -1910 { lab=Clk}
N 7660 -2240 7660 -2220 { lab=Q11}
N 7360 -1980 7460 -1980 { lab=RSTB}
N 7800 -2150 7800 -2080 { lab=#net36}
N 7800 -2040 7800 -1970 { lab=#net37}
N 7680 -1950 7680 -1860 { lab=#net34}
N 7680 -2130 7680 -2080 { lab=Q11}
N 7660 -2130 7680 -2130 { lab=Q11}
N 7660 -2220 7660 -2130 { lab=Q11}
N 7680 -2030 7680 -1990 { lab=#net38}
N 7800 -2170 7800 -2150 { lab=#net36}
N 7800 -2170 7930 -2170 { lab=#net36}
N 7800 -1970 7800 -1860 { lab=#net37}
N 7800 -1860 7940 -1860 { lab=#net37}
N 7360 -1860 7600 -1860 { lab=#net34}
N 7360 -2170 7680 -2170 { lab=#net33}
N 7930 -2170 7960 -2170 { lab=#net36}
N 7940 -1860 7960 -1860 { lab=#net37}
N 8090 -1910 8170 -1910 { lab=Clk}
N 8260 -2240 8260 -2220 { lab=Q12}
N 7960 -1980 8060 -1980 { lab=RSTB}
N 8400 -2150 8400 -2080 { lab=#net39}
N 8400 -2040 8400 -1970 { lab=#net40}
N 8280 -1950 8280 -1860 { lab=#net37}
N 8280 -2130 8280 -2080 { lab=Q12}
N 8260 -2130 8280 -2130 { lab=Q12}
N 8260 -2220 8260 -2130 { lab=Q12}
N 8280 -2030 8280 -1990 { lab=#net41}
N 8400 -2170 8400 -2150 { lab=#net39}
N 8400 -2170 8530 -2170 { lab=#net39}
N 8400 -1970 8400 -1860 { lab=#net40}
N 8400 -1860 8540 -1860 { lab=#net40}
N 7960 -1860 8200 -1860 { lab=#net37}
N 7960 -2170 8280 -2170 { lab=#net36}
N 8530 -2170 8560 -2170 { lab=#net39}
N 8540 -1860 8560 -1860 { lab=#net40}
N 7340 -1860 7360 -1860 { lab=#net34}
N 8690 -1910 8770 -1910 { lab=Clk}
N 8860 -2240 8860 -2220 { lab=Q13}
N 8560 -1980 8660 -1980 { lab=RSTB}
N 9000 -2150 9000 -2080 { lab=#net42}
N 9000 -2040 9000 -1970 { lab=#net43}
N 8880 -1950 8880 -1860 { lab=#net40}
N 8880 -2130 8880 -2080 { lab=Q13}
N 8860 -2130 8880 -2130 { lab=Q13}
N 8860 -2220 8860 -2130 { lab=Q13}
N 8880 -2030 8880 -1990 { lab=#net44}
N 9000 -2170 9000 -2150 { lab=#net42}
N 9000 -2170 9130 -2170 { lab=#net42}
N 9000 -1970 9000 -1860 { lab=#net43}
N 9000 -1860 9140 -1860 { lab=#net43}
N 8560 -1860 8800 -1860 { lab=#net40}
N 8560 -2170 8880 -2170 { lab=#net39}
N 9130 -2170 9160 -2170 { lab=#net42}
N 9290 -1910 9370 -1910 { lab=Clk}
N 9460 -2240 9460 -2220 { lab=Q14}
N 9160 -1980 9260 -1980 { lab=RSTB}
N 9600 -2150 9600 -2080 { lab=#net45}
N 9600 -2040 9600 -1970 { lab=#net46}
N 9480 -1950 9480 -1860 { lab=#net43}
N 9480 -2130 9480 -2080 { lab=Q14}
N 9460 -2130 9480 -2130 { lab=Q14}
N 9460 -2220 9460 -2130 { lab=Q14}
N 9480 -2030 9480 -1990 { lab=#net47}
N 9160 -1860 9400 -1860 { lab=#net43}
N 9160 -2170 9480 -2170 { lab=#net42}
N 9880 -1910 9960 -1910 { lab=Clk}
N 10060 -2240 10060 -2220 { lab=Q15}
N 9760 -1980 9860 -1980 { lab=RSTB}
N 10060 -2220 10060 -2130 { lab=Q15}
N 10060 -2030 10100 -2030 { lab=Q15_N}
N 9140 -1860 9160 -1860 { lab=#net43}
N 10060 -2130 10060 -2080 { lab=Q15}
N 9400 -1860 9480 -1860 { lab=#net43}
N 8800 -1860 8880 -1860 { lab=#net40}
N 8200 -1860 8280 -1860 { lab=#net37}
N 7600 -1860 7680 -1860 { lab=#net34}
N 7000 -1860 7080 -1860 { lab=#net31}
N 6400 -1860 6480 -1860 { lab=#net28}
N 5800 -1860 5880 -1860 { lab=#net25}
N 5200 -1860 5280 -1860 { lab=#net22}
N 4600 -1860 4680 -1860 { lab=#net19}
N 4000 -1860 4080 -1860 { lab=#net16}
N 3400 -1860 3480 -1860 { lab=#net13}
N 2800 -1860 2880 -1860 { lab=#net10}
N 2200 -1860 2280 -1860 { lab=#net6}
N 1600 -1860 1680 -1860 { lab=#net2}
N 1320 -2100 1340 -2100 {
lab=#net8}
N 1320 -2100 1320 -2080 {
lab=#net8}
N 1340 -2060 1340 -2040 {
lab=EN}
N 1320 -2040 1340 -2040 {
lab=EN}
N 3120 -2080 3120 -2060 { lab=#net48}
N 3120 -2100 3140 -2100 {
lab=#net48}
N 3120 -2100 3120 -2080 {
lab=#net48}
N 3140 -2060 3140 -2040 {
lab=EN}
N 3120 -2040 3140 -2040 {
lab=EN}
N 1920 -2080 1920 -2060 { lab=#net48}
N 1920 -2100 1940 -2100 {
lab=#net48}
N 1920 -2100 1920 -2080 {
lab=#net48}
N 1940 -2060 1940 -2040 {
lab=EN}
N 1920 -2040 1940 -2040 {
lab=EN}
N 2520 -2080 2520 -2060 { lab=#net48}
N 2520 -2100 2540 -2100 {
lab=#net48}
N 2520 -2100 2520 -2080 {
lab=#net48}
N 2540 -2060 2540 -2040 {
lab=EN}
N 2520 -2040 2540 -2040 {
lab=EN}
N 9720 -2080 9720 -2060 { lab=#net48}
N 9720 -2100 9740 -2100 {
lab=#net48}
N 9720 -2100 9720 -2080 {
lab=#net48}
N 9740 -2060 9740 -2040 {
lab=EN}
N 9720 -2040 9740 -2040 {
lab=EN}
N 3720 -2080 3720 -2060 { lab=#net48}
N 3720 -2100 3740 -2100 {
lab=#net48}
N 3720 -2100 3720 -2080 {
lab=#net48}
N 3740 -2060 3740 -2040 {
lab=EN}
N 3720 -2040 3740 -2040 {
lab=EN}
N 4320 -2080 4320 -2060 { lab=#net48}
N 4320 -2100 4340 -2100 {
lab=#net48}
N 4320 -2100 4320 -2080 {
lab=#net48}
N 4340 -2060 4340 -2040 {
lab=EN}
N 4320 -2040 4340 -2040 {
lab=EN}
N 4920 -2080 4920 -2060 { lab=#net48}
N 4920 -2100 4940 -2100 {
lab=#net48}
N 4920 -2100 4920 -2080 {
lab=#net48}
N 4940 -2060 4940 -2040 {
lab=EN}
N 4920 -2040 4940 -2040 {
lab=EN}
N 5520 -2080 5520 -2060 { lab=#net48}
N 5520 -2100 5540 -2100 {
lab=#net48}
N 5520 -2100 5520 -2080 {
lab=#net48}
N 5540 -2060 5540 -2040 {
lab=EN}
N 5520 -2040 5540 -2040 {
lab=EN}
N 6120 -2080 6120 -2060 { lab=#net48}
N 6120 -2100 6140 -2100 {
lab=#net48}
N 6120 -2100 6120 -2080 {
lab=#net48}
N 6140 -2060 6140 -2040 {
lab=EN}
N 6120 -2040 6140 -2040 {
lab=EN}
N 6720 -2080 6720 -2060 { lab=#net48}
N 6720 -2100 6740 -2100 {
lab=#net48}
N 6720 -2100 6720 -2080 {
lab=#net48}
N 6740 -2060 6740 -2040 {
lab=EN}
N 6720 -2040 6740 -2040 {
lab=EN}
N 7320 -2080 7320 -2060 { lab=#net48}
N 7320 -2100 7340 -2100 {
lab=#net48}
N 7320 -2100 7320 -2080 {
lab=#net48}
N 7340 -2060 7340 -2040 {
lab=EN}
N 7320 -2040 7340 -2040 {
lab=EN}
N 7920 -2080 7920 -2060 { lab=#net48}
N 7920 -2100 7940 -2100 {
lab=#net48}
N 7920 -2100 7920 -2080 {
lab=#net48}
N 7940 -2060 7940 -2040 {
lab=EN}
N 7920 -2040 7940 -2040 {
lab=EN}
N 8520 -2080 8520 -2060 { lab=#net48}
N 8520 -2100 8540 -2100 {
lab=#net48}
N 8520 -2100 8520 -2080 {
lab=#net48}
N 8540 -2060 8540 -2040 {
lab=EN}
N 8520 -2040 8540 -2040 {
lab=EN}
N 9120 -2080 9120 -2060 { lab=#net48}
N 9120 -2100 9140 -2100 {
lab=#net48}
N 9120 -2100 9120 -2080 {
lab=#net48}
N 9140 -2060 9140 -2040 {
lab=EN}
N 9120 -2040 9140 -2040 {
lab=EN}
C {devices/ipin.sym} 900 -1910 0 0 {name=p10 lab=Clk}
C {devices/ipin.sym} 770 -2080 0 0 {name=p21 lab=EN}
C {devices/opin.sym} 1060 -2230 3 0 {name=p22 lab=Q0}
C {sky130_stdcells/and2_1.sym} 1140 -2150 0 0 {name=x16 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 1910 -1660 0 0 {name=X17}
C {devices/ipin.sym} 770 -1980 0 0 {name=p23 lab=RSTB}
C {sky130_stdcells/or2_0.sym} 1260 -2060 0 0 {name=x17 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/inv_1.sym} 1040 -1860 0 0 {name=x18 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 1140 -1970 0 0 {name=x19 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/ipin.sym} 650 -2170 0 0 {name=p24 lab=U/D}
C {devices/opin.sym} 1660 -2230 3 0 {name=p27 lab=Q1}
C {sky130_stdcells/and2_1.sym} 1740 -2150 0 0 {name=x20 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 2510 -1660 0 0 {name=X18}
C {sky130_stdcells/and2_1.sym} 1740 -1970 0 0 {name=x23 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 1360 -1980 0 0 {name=l19 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 1490 -1910 0 0 {name=l20 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 2260 -2230 3 0 {name=p26 lab=Q2}
C {sky130_stdcells/and2_1.sym} 2340 -2150 0 0 {name=x28 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 3110 -1660 0 0 {name=X20}
C {sky130_stdcells/and2_1.sym} 2340 -1970 0 0 {name=x31 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 1960 -1980 0 0 {name=l23 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 2090 -1910 0 0 {name=l24 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 2860 -2230 3 0 {name=p28 lab=Q3}
C {sky130_stdcells/and2_1.sym} 2940 -2150 0 0 {name=x32 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 3710 -1660 0 0 {name=X21}
C {sky130_stdcells/and2_1.sym} 2940 -1970 0 0 {name=x35 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 2560 -1980 0 0 {name=l25 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 2690 -1910 0 0 {name=l26 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 3460 -2230 3 0 {name=p29 lab=Q4}
C {sky130_stdcells/and2_1.sym} 3540 -2150 0 0 {name=x36 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 4310 -1660 0 0 {name=X22}
C {sky130_stdcells/and2_1.sym} 3540 -1970 0 0 {name=x39 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 3290 -1910 0 0 {name=l27 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 4060 -2230 3 0 {name=p30 lab=Q5}
C {sky130_stdcells/and2_1.sym} 4140 -2150 0 0 {name=x40 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 4910 -1660 0 0 {name=X23}
C {sky130_stdcells/and2_1.sym} 4140 -1970 0 0 {name=x43 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 3760 -1980 0 0 {name=l28 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 3890 -1910 0 0 {name=l29 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 3160 -1980 0 0 {name=l30 sig_type=std_logic lab=RSTB}
C {devices/opin.sym} 4660 -2230 3 0 {name=p31 lab=Q6}
C {sky130_stdcells/and2_1.sym} 4740 -2150 0 0 {name=x44 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 5510 -1660 0 0 {name=X24}
C {sky130_stdcells/and2_1.sym} 4740 -1970 0 0 {name=x47 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 4490 -1910 0 0 {name=l31 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 5260 -2230 3 0 {name=p32 lab=Q7}
C {sky130_stdcells/and2_1.sym} 5340 -2150 0 0 {name=x48 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 6110 -1660 0 0 {name=X25}
C {sky130_stdcells/and2_1.sym} 5340 -1970 0 0 {name=x51 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 4960 -1980 0 0 {name=l32 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 5090 -1910 0 0 {name=l33 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 4360 -1980 0 0 {name=l34 sig_type=std_logic lab=RSTB}
C {devices/opin.sym} 5860 -2230 3 0 {name=p1 lab=Q8}
C {sky130_stdcells/and2_1.sym} 5940 -2150 0 0 {name=x1 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 6710 -1660 0 0 {name=X1}
C {sky130_stdcells/and2_1.sym} 5940 -1970 0 0 {name=x4 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 5690 -1910 0 0 {name=l1 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 6460 -2230 3 0 {name=p2 lab=Q9}
C {sky130_stdcells/and2_1.sym} 6540 -2150 0 0 {name=x5 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 7310 -1660 0 0 {name=X2}
C {sky130_stdcells/and2_1.sym} 6540 -1970 0 0 {name=x8 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 6290 -1910 0 0 {name=l2 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 7060 -2230 3 0 {name=p3 lab=Q10}
C {sky130_stdcells/and2_1.sym} 7140 -2150 0 0 {name=x9 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 7910 -1660 0 0 {name=X3}
C {sky130_stdcells/and2_1.sym} 7140 -1970 0 0 {name=x12 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 6760 -1980 0 0 {name=l3 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 6890 -1910 0 0 {name=l4 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 6160 -1980 0 0 {name=l5 sig_type=std_logic lab=RSTB}
C {devices/opin.sym} 7660 -2230 3 0 {name=p4 lab=Q11}
C {sky130_stdcells/and2_1.sym} 7740 -2150 0 0 {name=x13 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 8510 -1660 0 0 {name=X4}
C {sky130_stdcells/and2_1.sym} 7740 -1970 0 0 {name=x52 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 7490 -1910 0 0 {name=l6 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 8260 -2230 3 0 {name=p5 lab=Q12}
C {sky130_stdcells/and2_1.sym} 8340 -2150 0 0 {name=x53 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 9110 -1660 0 0 {name=X5}
C {sky130_stdcells/and2_1.sym} 8340 -1970 0 0 {name=x56 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 7960 -1980 0 0 {name=l7 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 8090 -1910 0 0 {name=l8 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 7360 -1980 0 0 {name=l9 sig_type=std_logic lab=RSTB}
C {devices/opin.sym} 8860 -2230 3 0 {name=p6 lab=Q13}
C {sky130_stdcells/and2_1.sym} 8940 -2150 0 0 {name=x57 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 9710 -1660 0 0 {name=X6}
C {sky130_stdcells/and2_1.sym} 8940 -1970 0 0 {name=x60 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 8560 -1980 0 0 {name=l10 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 8690 -1910 0 0 {name=l11 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 9460 -2230 3 0 {name=p7 lab=Q14}
C {sky130_stdcells/and2_1.sym} 9540 -2150 0 0 {name=x61 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {T_flip_flop/asyn_rst_t_ff.sym} 10310 -1660 0 0 {name=X7}
C {sky130_stdcells/and2_1.sym} 9540 -1970 0 0 {name=x64 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 9290 -1910 0 0 {name=l12 sig_type=std_logic lab=Clk}
C {devices/opin.sym} 10060 -2230 3 0 {name=p8 lab=Q15}
C {devices/lab_pin.sym} 9760 -1980 0 0 {name=l13 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 9880 -1910 0 0 {name=l14 sig_type=std_logic lab=Clk}
C {devices/lab_pin.sym} 9160 -1980 0 0 {name=l15 sig_type=std_logic lab=RSTB}
C {devices/lab_pin.sym} 10100 -2030 2 0 {name=l16 sig_type=std_logic lab=Q15_N}
C {devices/lab_pin.sym} 5560 -1980 0 0 {name=l17 sig_type=std_logic lab=RSTB}
C {T_flip_flop/asyn_st_tff.sym} 10440 -1630 0 0 {name=X8}
C {sky130_stdcells/and2_1.sym} 1400 -2080 0 0 {name=x3 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 1320 -2040 0 0 {name=l22 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 3060 -2060 0 0 {name=x7 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 3200 -2080 0 0 {name=x11 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 3120 -2040 0 0 {name=l36 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 1860 -2060 0 0 {name=x2 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 2000 -2080 0 0 {name=x6 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 1920 -2040 0 0 {name=l18 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 2460 -2060 0 0 {name=x10 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 2600 -2080 0 0 {name=x14 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 2520 -2040 0 0 {name=l21 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 9660 -2060 0 0 {name=x15 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 9800 -2080 0 0 {name=x21 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 9720 -2040 0 0 {name=l35 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 3660 -2060 0 0 {name=x22 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 3800 -2080 0 0 {name=x24 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 3720 -2040 0 0 {name=l37 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 4260 -2060 0 0 {name=x25 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 4400 -2080 0 0 {name=x26 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 4320 -2040 0 0 {name=l38 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 4860 -2060 0 0 {name=x27 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 5000 -2080 0 0 {name=x29 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 4920 -2040 0 0 {name=l39 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 5460 -2060 0 0 {name=x30 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 5600 -2080 0 0 {name=x33 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 5520 -2040 0 0 {name=l40 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 6060 -2060 0 0 {name=x34 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 6200 -2080 0 0 {name=x37 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 6120 -2040 0 0 {name=l41 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 6660 -2060 0 0 {name=x38 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 6800 -2080 0 0 {name=x41 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 6720 -2040 0 0 {name=l42 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 7260 -2060 0 0 {name=x42 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 7400 -2080 0 0 {name=x45 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 7320 -2040 0 0 {name=l43 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 7860 -2060 0 0 {name=x46 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 8000 -2080 0 0 {name=x49 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 7920 -2040 0 0 {name=l44 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 8460 -2060 0 0 {name=x50 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 8600 -2080 0 0 {name=x54 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 8520 -2040 0 0 {name=l45 sig_type=std_logic lab=EN}
C {sky130_stdcells/or2_0.sym} 9060 -2060 0 0 {name=x55 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/and2_1.sym} 9200 -2080 0 0 {name=x58 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {devices/lab_pin.sym} 9120 -2040 0 0 {name=l46 sig_type=std_logic lab=EN}
