* SPICE3 file created from filter_clkgen.ext - technology: sky130A

X0 cclkgen_0/inv_weak_pulldown_corrected_1/in cclkgen_0/inv_weak_pulldown_corrected_0/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=1.26e+06u l=180000u
X1 cclkgen_0/inv_weak_pulldown_corrected_0/a_30_50# cclkgen_0/inv_weak_pulldown_corrected_0/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X2 cclkgen_0/inv_weak_pulldown_corrected_1/in phigen_1/inv_weak_pulldown_corrected_0/vnb cclkgen_0/inv_weak_pulldown_corrected_0/a_30_50# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=540000u
X3 cclkgen_0/comp_clks_0/tg_0/inp cclkgen_0/inv_weak_pulldown_corrected_1/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=1.26e+06u l=180000u
X4 cclkgen_0/inv_weak_pulldown_corrected_1/a_30_50# cclkgen_0/inv_weak_pulldown_corrected_1/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X5 cclkgen_0/comp_clks_0/tg_0/inp phigen_1/inv_weak_pulldown_corrected_0/vnb cclkgen_0/inv_weak_pulldown_corrected_1/a_30_50# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=540000u
X6 cclkgen_0/comp_clks_0/tg_0/out GND cclkgen_0/comp_clks_0/tg_0/inp VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X7 cclkgen_0/comp_clks_0/tg_0/inp GND cclkgen_0/comp_clks_0/tg_0/out VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X8 cclkgen_0/comp_clks_0/tg_0/out VCCD cclkgen_0/comp_clks_0/tg_0/inp GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X9 cclkgen_0/comp_clks_0/inverter_1/in cclkgen_0/comp_clks_0/tg_0/inp GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X10 VCCD cclkgen_0/comp_clks_0/tg_0/inp cclkgen_0/comp_clks_0/inverter_1/in VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X11 cclkgen_0/comp_clks_0/inverter_1/in cclkgen_0/comp_clks_0/tg_0/inp VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X12 cclkgen_0/comp_clks_0/inverter_1/out cclkgen_0/comp_clks_0/inverter_1/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X13 VCCD cclkgen_0/comp_clks_0/inverter_1/in cclkgen_0/comp_clks_0/inverter_1/out VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X14 cclkgen_0/comp_clks_0/inverter_1/out cclkgen_0/comp_clks_0/inverter_1/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X15 cclkgen_0/comp_clks_0/inverter_2/out cclkgen_0/comp_clks_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X16 VCCD cclkgen_0/comp_clks_0/tg_0/out cclkgen_0/comp_clks_0/inverter_2/out VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X17 cclkgen_0/comp_clks_0/inverter_2/out cclkgen_0/comp_clks_0/tg_0/out VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X18 phigen_1/inv_weak_pullup_corrected_0/inp phigen_1/inv_weak_pulldown_corrected_0/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=1.26e+06u l=180000u
X19 phigen_1/inv_weak_pulldown_corrected_0/a_30_50# phigen_1/inv_weak_pulldown_corrected_0/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X20 phigen_1/inv_weak_pullup_corrected_0/inp phigen_1/inv_weak_pulldown_corrected_0/vnb phigen_1/inv_weak_pulldown_corrected_0/a_30_50# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=540000u
X21 phigen_1/inv_weak_pullup_corrected_0/out phigen_1/inv_weak_pullup_corrected_0/vpb phigen_1/inv_weak_pullup_corrected_0/a_234_496# VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.26e+06u l=540000u
X22 phigen_1/inv_weak_pullup_corrected_0/a_234_496# phigen_1/inv_weak_pullup_corrected_0/inp VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=1.26e+06u l=180000u
X23 phigen_1/inv_weak_pullup_corrected_0/out phigen_1/inv_weak_pullup_corrected_0/inp GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X24 phigen_1/comp_clks_0/tg_0/out GND phigen_1/inv_weak_pullup_corrected_0/out VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X25 phigen_1/inv_weak_pullup_corrected_0/out GND phigen_1/comp_clks_0/tg_0/out VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X26 phigen_1/comp_clks_0/tg_0/out VCCD phigen_1/inv_weak_pullup_corrected_0/out GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X27 phigen_1/comp_clks_0/inverter_1/in phigen_1/inv_weak_pullup_corrected_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X28 VCCD phigen_1/inv_weak_pullup_corrected_0/out phigen_1/comp_clks_0/inverter_1/in VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X29 phigen_1/comp_clks_0/inverter_1/in phigen_1/inv_weak_pullup_corrected_0/out VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X30 phigen_1/comp_clks_0/inverter_1/out phigen_1/comp_clks_0/inverter_1/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X31 VCCD phigen_1/comp_clks_0/inverter_1/in phigen_1/comp_clks_0/inverter_1/out VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X32 phigen_1/comp_clks_0/inverter_1/out phigen_1/comp_clks_0/inverter_1/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X33 phigen_1/comp_clks_0/inverter_2/out phigen_1/comp_clks_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X34 VCCD phigen_1/comp_clks_0/tg_0/out phigen_1/comp_clks_0/inverter_2/out VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X35 phigen_1/comp_clks_0/inverter_2/out phigen_1/comp_clks_0/tg_0/out VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X36 phigen_0/inv_weak_pullup_corrected_0/inp phigen_0/inv_weak_pulldown_corrected_0/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=1.26e+06u l=180000u
X37 phigen_0/inv_weak_pulldown_corrected_0/a_30_50# phigen_0/inv_weak_pulldown_corrected_0/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X38 phigen_0/inv_weak_pullup_corrected_0/inp phigen_1/inv_weak_pulldown_corrected_0/vnb phigen_0/inv_weak_pulldown_corrected_0/a_30_50# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=540000u
X39 phigen_0/inv_weak_pullup_corrected_0/out phigen_1/inv_weak_pullup_corrected_0/vpb phigen_0/inv_weak_pullup_corrected_0/a_234_496# VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.26e+06u l=540000u
X40 phigen_0/inv_weak_pullup_corrected_0/a_234_496# phigen_0/inv_weak_pullup_corrected_0/inp VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=1.26e+06u l=180000u
X41 phigen_0/inv_weak_pullup_corrected_0/out phigen_0/inv_weak_pullup_corrected_0/inp GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X42 phigen_0/comp_clks_0/tg_0/out GND phigen_0/inv_weak_pullup_corrected_0/out VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X43 phigen_0/inv_weak_pullup_corrected_0/out GND phigen_0/comp_clks_0/tg_0/out VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X44 phigen_0/comp_clks_0/tg_0/out VCCD phigen_0/inv_weak_pullup_corrected_0/out GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X45 phigen_0/comp_clks_0/inverter_1/in phigen_0/inv_weak_pullup_corrected_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X46 VCCD phigen_0/inv_weak_pullup_corrected_0/out phigen_0/comp_clks_0/inverter_1/in VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X47 phigen_0/comp_clks_0/inverter_1/in phigen_0/inv_weak_pullup_corrected_0/out VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X48 phigen_0/comp_clks_0/inverter_1/out phigen_0/comp_clks_0/inverter_1/in GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X49 VCCD phigen_0/comp_clks_0/inverter_1/in phigen_0/comp_clks_0/inverter_1/out VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X50 phigen_0/comp_clks_0/inverter_1/out phigen_0/comp_clks_0/inverter_1/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X51 phigen_0/comp_clks_0/inverter_2/out phigen_0/comp_clks_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X52 VCCD phigen_0/comp_clks_0/tg_0/out phigen_0/comp_clks_0/inverter_2/out VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=630000u l=180000u
X53 phigen_0/comp_clks_0/inverter_2/out phigen_0/comp_clks_0/tg_0/out VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=630000u l=180000u
X54 level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out GND div2 VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X55 div2 GND level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X56 level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out VDD1 div2 GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X57 level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out div2 GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X58 VDD1 div2 level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X59 level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out div2 VDD1 VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X60 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X61 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X62 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X63 GND level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X64 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X65 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X66 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X67 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X68 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X69 GND level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X70 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X71 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X72 GND level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X73 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X74 phigen_0/inv_weak_pulldown_corrected_0/in phigen_1/inv_weak_pulldown_corrected_0/in VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=420000u l=150000u
X75 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X76 GND level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X77 GND level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X78 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X79 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X80 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X81 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X82 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X83 GND level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X84 VCCD phigen_0/inv_weak_pulldown_corrected_0/in phigen_1/inv_weak_pulldown_corrected_0/in VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=420000u l=150000u
X85 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X86 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X87 GND level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X88 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X89 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X90 GND level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_1/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X91 phigen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X92 phigen_1/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_0/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X93 VCCD level_up_shifter_d_a_0/comp_clks_stg1_0/inverter_0/out phigen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X94 level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out GND level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/inp VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X95 level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/inp GND level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X96 level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out VDD1 level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/inp GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X97 level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/inp GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=180000u
X98 VDD1 level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/inp level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X99 level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/inp VDD1 VDD1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=630000u l=180000u
X100 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X101 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X102 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X103 GND level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X104 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X105 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X106 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X107 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X108 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X109 GND level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X110 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X111 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X112 GND level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X113 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X114 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/a_1260_620# VCCD VCCD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=-0p ps=0u w=420000u l=150000u
X115 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X116 GND level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X117 GND level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X118 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X119 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X120 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X121 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X122 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X123 GND level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X124 VCCD cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/a_1260_620# VCCD sky130_fd_pr__pfet_01v8 ad=-0p pd=0u as=0p ps=0u w=420000u l=150000u
X125 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
X126 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X127 GND level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X128 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X129 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X130 GND level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out level_up_shifter_d_a_1/a_1260_620# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X131 cclkgen_0/inv_weak_pulldown_corrected_0/in level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out GND GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=600000u l=150000u
X132 level_up_shifter_d_a_1/a_1260_620# level_up_shifter_d_a_1/comp_clks_stg1_0/tg_0/out VCCD GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=-0p ps=0u w=600000u l=150000u
X133 VCCD level_up_shifter_d_a_1/comp_clks_stg1_0/inverter_0/out cclkgen_0/inv_weak_pulldown_corrected_0/in GND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=600000u l=150000u
