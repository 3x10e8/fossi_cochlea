v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {top/unison2.sym} 0 -120 0 0 {}
C {top/unison2.sym} 0 120 0 0 {}
C {top/unison2.sym} 0 -360 0 0 {}
C {top/unison2.sym} 0 360 0 0 {}
