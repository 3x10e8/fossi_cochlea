v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
B 10 -2.5 -2.5 2.5 2.5 {}
