v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {top/unison1.sym} 0 -160 0 0 {name=x1}
C {top/unison1.sym} 0 160 2 1 {name=x2}
