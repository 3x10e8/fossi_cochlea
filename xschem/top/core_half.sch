v {xschem version=3.0.0 file_version=1.2 }
G {}
K {type=subcircuit
format="@name @pinlist @symname"
template="name=x1"}
V {}
S {}
E {}
L 6 70 25 70 30 {}
L 6 50 30 70 30 {}
L 6 0 80 80 80 {}
L 6 2 68 2 80 {}
L 6 5 60 30 60 {}
L 6 30 -40 30 60 {}
L 21 0 -61 80 -61 {}
L 21 80 -76 80 -61 {}
L 21 37 -72 41 -70 {}
L 21 37 -72 37 -68 {}
L 21 37 -68 41 -70 {}
L 21 46 -70 50 -70 {}
L 21 48 -66 80 -66 {}
L 21 48 -74 80 -74 {}
L 21 42 -70 80 -70 {}
L 21 39 -73 39 -71 {}
L 21 36 -73 39 -73 {}
L 21 0 -76 80 -76 {}
L 21 70 -60 70 15 {}
L 21 0 -60 0 -45 {}
L 21 5 -60 5 -45 {}
L 21 15 -60 15 -45 {}
L 21 0 -35 0 60 {}
C {top/c1.sym} 30 30 0 0 {}
C {top/c2.sym} 30 -15 0 0 {}
C {top/c3.sym} 30 -40 0 0 {}
C {top/cs.sym} 30 60 0 0 {}
C {top/cs.sym} 30 0 0 0 {}
C {top/cs.sym} 15 -40 0 0 {}
C {top/comp.sym} 0 -40 0 0 {}
C {top/inv.sym} 70 20 0 0 {}
C {top/mux.sym} 0 60 3 0 {}
