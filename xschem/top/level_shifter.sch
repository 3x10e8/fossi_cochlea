v {xschem version=3.0.0 file_version=1.2 }
G {}
K {type=subcircuit
format="@name @pinlist @symname"
template="name=x1"
}
V {}
S {}
E {}
L 4 -4 -3 0 3 {}
L 4 -4 -3 4 -3 {}
L 4 0 3 4 -3 {}
L 4 -4 -1 0 5 {}
L 4 0 5 4 -1 {}
L 4 -4 -1 -3 -1 {}
L 4 3 -1 4 -1 {}
L 4 -5 2 -2 2 {}
L 4 2 2 5.5 2 {}
L 4 -5 -3 -4 -3 {}
L 4 4 -3 5.5 -3 {}
