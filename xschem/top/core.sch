v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {top/core_half.sym} 0 0 0 0 {name=x1}
C {top/core_half.sym} 0 0 0 1 {name=x2}
